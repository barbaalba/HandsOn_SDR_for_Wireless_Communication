options:
  parameters:
    generate_options: qt_gui
    id: frequency_analyzer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ant_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 2.4e9
    step: 10e6
    stop: 2.5e9
    value: 2.437e9
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 2e6
    stop: 40e6
    value: 25e6
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    name: '"Spectrum"'
    showports: 'True'
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: samp_rate
    center_freq0: freq
    dev_args: otw_format=sc8
    gain0: ant_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
